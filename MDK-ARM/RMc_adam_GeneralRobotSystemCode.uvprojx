# Keil uVision project RMc_adam_GeneralRobotSystemCode.uvprojx, settings and files
target RMc_adam_GeneralRobotSystemCode (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: RMc_adam_GeneralRobotSystemCode +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Drivers/Chip;../Task;../Algorithm;../Applications/Software;../Applications/Hardware;../Drivers/Nooloop;../Applications/Software/UI
  asm include: ..\Inc;../Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/User
    ../Src/: main.c gpio.c freertos.c can.c crc.c dma.c i2c.c iwdg.c spi.c tim.c usart.c usb_device.c usbd_conf.c usbd_desc.c usbd_cdc_if.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Algorithm
    ../Algorithm/: pid.c fifo.c madgwick.c MahonyAHRS.c Kalman_Filter_c.c CRC8_CRC16.c AHRS.lib AHRS_middleware.c libalgobsx.lib bsxlite_interface.h RampFunc.c
  group Applicantions/Hardware
    ../Applications/Hardware/: IMU_updata.c CAN_receive&send.c UART_data_transmit.c DBUS_remote_control.c GPIO_output.c GPIO_input_EXTI.c LED_control.c USB_VirCom.c PWM_control.c Stm32_time.c cap_ctl.c LK_motor_process.c can_bsp.c can_bsp.h
  group Applications/Software
    ../Applications/Software/: global_status.c Error_detect.c chassis_move.c gimbal.c shoot.c NUC_communication.c referee_handle_pack.c referee_usart_task.c RM_Cilent_UI.c control_setting.c Stxxid-Data-Transmission.c vofa.c HT_drive.c CAN_ID_Library.h
    ../Applications/Software/UI/: ui.c ui.h ui_interface.c ui_interface.h ui_types.h ui_default_aim_0.c ui_default_aim_0.h ui_default_chassis_0.c ui_default_chassis_0.h ui_default_energy_0.c ui_default_energy_0.h ui_default_gimbal_0.c ui_default_gimbal_0.h ui_default_shoot_0.c ui_default_shoot_0.h ui_default_state_0.c ui_default_state_0.h ui_default_state_1.c ui_default_state_1.h ui_default_state_2.c ui_default_state_2.h ui_default_close_aim_0.c ui_default_close_aim_0.h
    ../Applications/Hardware/: dm4310_drv.c dm4310_drv.h
  group Drives/Chip
    ../Drivers/Chip/: BMI088driver.c BMI088Middleware.c ist8310driver.c ist8310driver_middleware.c
    ../Drivers/Nooloop/: nlink_tofsense_frame0.c nlink_utils.c nloop_middlewares.c
  group Drivers/CMSIS
    ./: startup_stm32f407xx.s
    ../Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_crc.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
software components: CMSIS:CORE 4.3.0, CMSIS:DSP 1.4.6
